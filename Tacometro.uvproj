# Keil uVision project Tacometro.uvproj, settings and files
target Tacometro (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Tacometro +hex
  c flags: Optimize=9
  c include: .\inc
  link misc: CODE(0x0100 - 0xef00)
  group source
    ./src/: main.c inicializacion.c isr.c mdt.c firm_lcd.c barrido_teclado.c buffer.c firm_calib.c
  group includes
    ./inc/: c8051F020.h inicializacion.h main.h mdt.h firm_lcd.h barrido_teclado.h buffer.h firm_calib.h
  group Documentacion
    ./: Abstract.txt
